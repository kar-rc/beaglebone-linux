## ldd/source/linux/drivers/char/my_c_dev/Kconfig
```kconfig
menu "helloworld custom modules"
config CUSTOM_HELLOWORLD
	tristate "HelloWorld Module Support"
	default n
endmenu
```
